# Keil uVision project Lab15.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab15
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Lab15
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group hardware
    ../hardware/: ADC.c ADC.h Buttons.c Buttons.h DAC.c DAC.h LED.c LED.h Nokia5110.c Nokia5110.h PLL.c PLL.h Sound.c Sound.h startup.s SysTick.c SysTick.h Timer0.c Timer0.h tm4c123gh6pm.h UART.c UART.h Timer1.c Timer1.h Timer2.c Timer2.h Timer3.c Timer3.h Timer4.c Timer4.h Timer5.c Timer5.h
  group gameLogic
    ../gameLogic/: bitmaps.c bitmaps.h player.c player.h projectile.c projectile.h random.h random.s enemies.c enemies.h collidable.h explosions.c explosions.h
  group main
    ../: main.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
